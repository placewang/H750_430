# Keil uVision project CODE.uvprojx, settings and files
target CODE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750ZBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00080000) IROM2(0x08100000,0x00080000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CODE +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c misc: --diag_suppress=68,111,188,223,546,1295
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/app;../User/bsp;../Middlewares/LVGL/GUI;../Middlewares/LVGL/GUI/lvgl;../Middlewares/LVGL/GUI/lvgl/src;../Middlewares/LVGL/GUI/lvgl/examples/porting;../Middlewares/LVGL/GUI_APP/demos;../Middlewares/LVGL/GUI_APP/demos/stress;../Middlewares/LVGL/GUI_APP/demos/widgets;../Middlewares/LVGL/GUI_APP/demos/music;../Middlewares/LVGL/MY_GUI;../Middlewares/LVGL/MY_GUI/components;../MVP/View;../MVP/Model;../MVP/Presenter
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24040000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c fdcan.c fmc.c ltdc.c rtc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/LVGL/GUI/lvgl/examples/porting
    ../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/LVGL/GUI/lvgl/src/core
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/LVGL/GUI/lvgl/src/draw
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/LVGL/GUI/lvgl/src/extra
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group Middlewares/LVGL/GUI/lvgl/src/font
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/GUI/lvgl/src/gpu
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middlewares/LVGL/GUI/lvgl/src/hal
    ../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/GUI/lvgl/src/misc
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/GUI/lvgl/src/widgets
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group User/bsp
    ../User/bsp/: bsp_lcd.c bsp_touch.c bsp_mx25l_spi.c bsp_ad7843.c bsp_sdram.c bsp_uart.c bsp_encoder.c bsp_rtc.c bsp_iic.c bsp_gt911.c bsp_TouchSet.c bsp_dcan.c
  group User/app
    ../User/app/: app_config.c app_version.h app_queue.c app_balanceRoll_code.c app_sdo.c app_delta_servo.c app_pid.c app_DischargeSystem.c app_DischargeGUI_config.c app_HqServoProtocol.c app_RowknifeSystem.c app_RwKf_pid.c
  group Middlewares/LVGL/GUI_APP
    ../Middlewares/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../Middlewares/LVGL/GUI_APP/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../Middlewares/LVGL/GUI_APP/demos/widgets/: lv_demo_widgets.c
    ../Middlewares/LVGL/GUI_APP/demos/benchmark/: lv_demo_benchmark.c
    ../Middlewares/LVGL/GUI_APP/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Middlewares/LVGL/GUI_APP/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Middlewares/LVGL/GUI_APP/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group Middlewares/LVGL/MY_GUI
    ../Middlewares/LVGL/MY_GUI/: ui.c ui_helpers.c ui_my_deal.c ui_events.c ui_my_config.c ui_my_mode1.c ui_my_MAIN.c
    ../Middlewares/LVGL/MY_GUI/screens/: ui_MAIN.c ui_set.c ui_mode1.c ui_config.c
    ../Middlewares/LVGL/MY_GUI/fonts/: ui_font_CN14.c ui_font_CN20.c
    ../Middlewares/LVGL/MY_GUI/components/: ui_comp_hook.c ui_comp.c
  group Middlewares/LVGL/MY_GUI_EXT_FLASH
    ../Middlewares/LVGL/MY_GUI/images/: ui_img_kunrunlogo_png.c ui_img_frame_724a_png.c ui_img_frame_728_png.c ui_img_frame_723a_png.c ui_img_frame_723b_png.c ui_img_107039415.c ui_img_267240549.c ui_img_305905464.c ui_img_338428369.c ui_img_422176665.c ui_img_624903647.c ui_img_735046482.c ui_img_810446530.c ui_img_1156819174.c ui_img_1317020308.c ui_img_1352985776.c ui_img_1388208128.c ui_img_1453726105.c ui_img_1538528659.c ui_img_1784826241.c ui_img_2113159062.c ui_img_bg_init_png.c ui_img_whq_png.c ui_img_frame_724b_png.c
  group User/ext_flash
    ../User/ext_flash/: test.c
  group MVP/Model
    ../MVP/Model/: m_set.c
  group MVP/Presenter
    ../MVP/Presenter/: p_set.c
  group MVP/View
    ../MVP/View/: ui_my_set.c
software components: CMSIS:CORE 5.4.0
